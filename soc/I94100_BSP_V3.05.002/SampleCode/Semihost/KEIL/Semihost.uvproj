# Keil uVision project Semihost.uvproj, settings and files
target Semihost (ARM-ADS)
  device: I94120 Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(100000000) CPUTYPE("Cortex-M4") FPU2
  output: Semihost
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\Library\Device\Nuvoton\I94100\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\I94100
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_I94100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
    ./: startup_I94100.s
  group User
    ../: main.c
    ../../../Library/StdDriver/src/: clk.c sys.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c
