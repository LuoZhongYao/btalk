# Keil uVision project USBD_HID_Transfer.uvproj, settings and files
target USBD_MTP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: I94120 Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: MTP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: DISABLE_UART,DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\I94100\Include;..\..\..\..\Library\Device\Nuvoton\I94100;..\
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_I94100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
    ./: startup_I94100.s
  group User
    ../: readme.txt main.c ConfigSysClk.h SysClk.c mtp_desc.c usb_mtp.c
  group Libraries
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c usbd.c uart.c gpio.c timer.c
